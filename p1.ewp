# IAR project p1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\softwares\IAR arm\arm\CMSIS\Include; D:\softwares\TI-CMSIS\TI\LM4F\Include; D:\softwares\Tiva lib\driverlib; D:\softwares\Tiva lib\grlib; D:\softwares\Tiva lib\inc; D:\softwares\Tiva lib\sensorlib; D:\softwares\Tiva lib\usblib; D:\softwares\Tiva lib\utils
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: p1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: D:\softwares\Tiva lib\driverlib\rvmdk\driverlib.lib; D:\softwares\Tiva lib\grlib\rvmdk\grlib.lib; D:\softwares\Tiva lib\usblib\rvmdk\usblib.lib; D:\softwares\Tiva lib\sensorlib\ccs\Debug\sensorlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.c servo.c servo.h
